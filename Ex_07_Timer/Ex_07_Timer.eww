<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\Ex_07_Timer_easy\Ex_07_Timer.ewp</path>
    </project>
    <batchBuild />
</workspace>

<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Ex_06_Exception.ewp</path>
    </project>
    <batchBuild />
</workspace>

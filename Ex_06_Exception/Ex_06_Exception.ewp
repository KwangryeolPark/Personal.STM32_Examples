# IAR project Ex_06_Exception.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: E:\ARM\res\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\iar; E:\ARM\res\stm32; E:\ARM\res\cortex_m3; E:\ARM\res; E:\ARM\res\stdio
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Ex_06_Exception.hex
  ILINK.IlinkOutputFile: Ex_06_Exception.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f103xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../res/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd_vl.s
  group Ex_06_Exception
    ./: Ex_06_Exception.c
  group res/cortex_m3
    ../../res/cortex_m3/: nvic.h
  group res/stm32
    ../../res/stm32/: afio.h exti.h gpio.h rcc.h

<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Ex_05_GPIO_Input.ewp</path>
    </project>
    <batchBuild />
</workspace>
